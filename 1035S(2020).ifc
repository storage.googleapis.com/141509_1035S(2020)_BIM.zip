Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-10T22:38:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 10 22:38:30 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{CA037EDA-D116-4703-8A74-7BB55B981DE8}\ifc * Database version: 5507 * Database creation date: Fri Apr 10 22:38:29 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 10 22:38:30 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 10 22:38:30 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1035S Kitchen faucet with dishwasher valve, 1035S(2020):1035S Kitchen faucet with dishwasher valve:341543
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 254 mm; NominalHeight: 183.6 mm; NominalWidth: 53.6 mm; Projection: 213 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1035S(2020); ConvergoRefNr: 0087-2003-0071-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 03/04/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150096334; EN Standard: EN 817; LVI Number: 6219166
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1035S; Catalog Drawing URL: http://static.oras.com/catdrw/1035S; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1035S; FDV Document URL: http://www.oras.com/datasheet/1035S/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1035S; Group: Kitchen faucets; Manufacturer: Oras; Market: INT;FIN;POL;RUS;EST;LTU;LVA; Model: 1035S Kitchen faucet with dishwasher valve; Name_en: 1035S Kitchen faucet with dishwasher valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 590 x 290 x 65; Package Weight: 2.14 kg; Product Code: 1035S; Product Datasheet: http://www.oras.com/datasheet/1035S/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1035S; Product URL: http://static.oras.com/1035S; Type Name: 1035S Kitchen faucet with dishwasher valve
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass;3S-Installation; Aerator: CASCADE®; Connection: CopperInletPipes; Connection Size: G3/8; Dishwasher Valve: Dishwasher valve; Flow Rate At 300kPa: 0.00953496 m3/s; Installation and Maintenance: http://static.oras.com/manual/1035S; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1 Mounting Hole; Noise Class: I(ISO 3822); Pressure Loss With Flow 02ls: 160000 Pa; Spare Parts: http://static.oras.com/sp/1035S; Spout Swivel Range: 120° (80° / 40°); Spout Type: Swivel spout; Temperature Adjustments: Temperature limiter
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1035S(2020); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1035S; Name: 1035S Kitchen faucet with dishwasher valve; ReplacementCost: n/a; Shape: Sculptured; Size: 254 x 183 x 54 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1035S; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1035S Kitchen faucet with dishwasher valve
Constraints - DefaultElevation: 700 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0711607 m2; Volume: 0.00250305 m3
Identity Data - Mark: 10
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1035S(2020): 1035S Kitchen faucet with dishwasher valve; Family and Type: 1035S(2020): 1035S Kitchen faucet with dishwasher valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1035S(2020): 1035S Kitchen faucet with dishwasher valve; Type Id: 1035S(2020): 1035S Kitchen faucet with dishwasher valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
